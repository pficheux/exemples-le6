FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://dt-overlay.cfg"
