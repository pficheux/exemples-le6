FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-updated-message.patch"

# Force package upgrade
PR= "r1"


